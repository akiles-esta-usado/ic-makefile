v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 0 -50 0 -30 {}
N 0 30 -0 50 {}
C {sky130_fd_pr/cap_mim_m3_1.sym} 0 0 0 0 {name=C1_B model=cap_mim_m3_1 W=10 L=10 MF=1 spiceprefix=X}
C {devices/iopin.sym} 0 -50 0 0 {name=p1 lab=c0}
C {devices/iopin.sym} 0 50 0 0 {name=p2 lab=c1}
